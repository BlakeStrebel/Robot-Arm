Commit message: updated urdf

File: urdf/r2_robot.urdf (robot description, URDF)
Before this commit: robot flexible, 4 links, 3 joints
Links:
- link end: geometry visual box size=0 0 0
